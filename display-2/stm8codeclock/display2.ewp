# IAR project display2.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052C6 STM8L052C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: display2.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: display2.out
  group (top)
    ./: lcd.h main.c pins.h rtc.h stm8l.h
